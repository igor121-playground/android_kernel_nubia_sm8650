## drivers/vendor/common/game_sw/Kconfig
```kconfig
config NUBIA_GAME_SW
	tristate "Nubia sliding switch driver"
	default n
	depends on GPIOLIB
```
